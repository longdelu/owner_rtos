# Keil uVision project myrtos.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: myrtos
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\usr
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group usr
    ../usr/: main.c rtos_task.c rtos_task_switch.c rtos_systick.c rtos_task_delay.c rtos_task_critical.c rtos_task_bitmap.c rtos_config.h rtos_task_list.c rtos_list.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
