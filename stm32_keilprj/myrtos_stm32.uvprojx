# Keil uVision project myrtos_stm32.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myrtos_stm32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,SUPPORT_OS,LWIP_NO_SUPPORT_OS
  c include: ..\usr;..\rtos;..\soc\stm32f4xx\include;..\soc\stm32f4xx\include\legacy;..\usr_conf;..\core;..\components\libc\microlib\include;..\usr_conf\include;..\components\usmart\include;..\device\include;..\usr\i2c;..\usr\sram;..\usr\malloc;..\usr\lwip_app\lwip_comm;..\components\lwip\lwip-1.4.1\src\include;..\components\lwip\lwip-1.4.1\src\netif;..\components\lwip\lwip-1.4.1\src\include\ipv4;..\components\lwip\lwip-1.4.1\arch;..\startup;..\components\lwip\lwip-1.4.1\src\include\netif
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr
    ../usr/: main.c
    ../usr/sram/: sdram.c
    ../usr/i2c/: myiic.c
    ../usr/malloc/: malloc.c
    ../usr/lwip_app/lwip_comm/: lwip_comm.c
  group hal
    ../soc/stm32f4xx/driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_eth.c
  group rtos
    ../rtos/: rtos_init.c rtos_task.c rtos_list.c rtos_mbox.c rtos_memblock.c rtos_mutex_sem.c rtos_sem.c rtos_soft_timer.c rtos_systick.c rtos_task_bitmap.c rtos_task_critical.c rtos_task_delay.c rtos_task_event.c rtos_task_list.c rtos_task_switch.c rtos_flaggroup.c rtos_cpu_use.c rtos_hook.c rtos_common.h rtos_config.h readme.h rtos_cpu.c
  group usr_conf
    ../usr_conf/: stm32f4xx_hal_conf.h
    ../soc/stm32f4xx/include/: stm32f4xx_hal.h
    ../usr_conf/sourse/: stm32f4xx_hal_clk_init.c stm32f4xx_hal_led_init.c stm32f4xx_hal_uart_init.c stm32f4xx_hal_tim_init.c stm32f4xx_hal_gpio_init.c
  group core
    ../core/: core_cmSimd.h core_cmInstr.h core_cmFunc.h core_cm4.h cmsis_armcc.h
  group startup
    ../startup/: system_stm32f4xx.c startup_stm32f429xx.s
  group component
    ../components/libc/microlib/sources/: microlib_adapter.c
  group device
    ../device/source/LAN8720/: lan8720.c
    ../device/source/PCF8574/: pcf8574.c
  group lwip_netif
    ../components/lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwip_core
    ../components/lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../components/lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip_api
    ../components/lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../components/lwip/lwip-1.4.1/arch/: sys_arch.c
